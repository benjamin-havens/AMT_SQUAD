options:
  parameters:
    generate_options: qt_gui
    id: spectrum_analyzer
    output_language: python
    title: spectrum_analyzer
  states: {}

blocks:
- name: agc
  id: variable_qtgui_chooser
  parameters:
    label: Automatic Gain Control
    label0: Disabled
    label1: Enabled
    num_opts: '2'
    option1: Enabled
    type: string
    value: Disabled
  states: {state: disabled}
- name: rf0_gain
  id: variable_qtgui_range
  parameters:
    label: RF_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: rf1_gain
  id: variable_qtgui_range
  parameters:
    label: RF_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: 192e3
    step: '1000'
    stop: 56e6
    value: 20e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 1000e6
    step: 100e6
    stop: 2000e6
    value: 1485e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    alias: test
    bw: 5e6
    fc: tuning
    fftsize: '1024'
    name: Spectrum Analyzer A
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 5e6
    fc: tuning
    fftsize: '1024'
    name: Spectrum Analyzer B
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: RX2
    bw0: 10e6
    bw1: 10e6
    center_freq0: tuning
    center_freq1: tuning
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_args: '""'
    gain0: rf0_gain
    gain1: rf1_gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
